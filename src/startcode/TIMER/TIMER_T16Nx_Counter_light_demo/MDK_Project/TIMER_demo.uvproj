# Keil uVision project TIMER_demo.uvproj, settings and files
target TIMER_demo (ARM-ADS)
  device: ES8H508x ES
  cpu: IRAM(0x20000000-0x20003FFF)  IROM(0x00000000-0x00011FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: TIMER_demo +hex
  c flags: Optim=1
  c misc: --bitband
  c include: ..\..\..\..\Library\Include;..\..\..\..\CMSIS;..\PlatForm;..\APP
  memory RVCT4: ROM 0x0 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ../../../../MDK_StartUp/: startup_ES8P508x.s
  group CMSIS
    ../../../../CMSIS/: system_ES8P508x.c
  group Library
    ../../../../Library/Source/: lib_adc.c lib_flashiap.c lib_gpio.c lib_iic.c lib_printf.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group APP
    ../APP/: main.c key.c led.c light.c systick.c timer.c
