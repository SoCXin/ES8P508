# IAR project IIC_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ES8P508x Eastsoft ES8P508x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\APP; ..\..\..\..\..\CMSIS; ..\..\..\..\..\IAR_StartUp; ..\..\..\..\..\Library\Include; ..\..\..\..\..\Library\Source; ..\PlatForm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: IIC_demo.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: iic.c main.c
  group CMSIS
    ../../../../../CMSIS/: system_ES8P508x.c
  group Library
    ../../../../../Library/Source/: lib_adc.c lib_aes.c lib_crc.c lib_flashiap.c lib_gpio.c lib_iap.c lib_iic.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group StartUp
    ../../../../../IAR_StartUp/: startup_hr8p508x.s
