<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\AES\AES_demo\IAR_Project\AES_demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\CRC\CRC_demo\IAR_project\CRC_demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\GPIO\GPIO_CombinationKey_demo\IAR_Proect\GPIO_demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
