# Keil uVision project ADC_demo.uvproj, settings and files
target ADC_demo (ARM-ADS)
  device: ES8P508xFLXX ES
  cpu: IRAM(0x20000000-0x20005FFF)  IROM(0x00000000-0x0001FFFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: adc_demo +hex
  c flags: Optim=1
  c define: HR8P286FLLT,__PRINTF_USE_UART0__
  c misc: --bitband
  c include: ..\APP;..\PlatForm;..\..\..\..\Library\Include;..\..\..\..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group StartUp
    ../../../../MDK_StartUp/: startup_ES8P508x.s
  group CMSIS
    ../../../../CMSIS/: system_ES8P508x.c
  group Library
    ../../../../Library/Source/: lib_adc.c lib_aes.c lib_crc.c lib_flashiap.c lib_gpio.c lib_iap.c lib_iic.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group APP
    ../APP/: adc.c key.c led.c main.c systick.c timer.c
