# IAR project APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ES8H508x Eastsoft ES8H508x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Source; ..\..\..\CMSIS; ..\..\..\IAR_StartUp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: APP.hex
  ILINK.IlinkOutputFile: APP.out
  ILINK.IlinkIcfFile: ES8H508x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../CMSIS/: core_cm0.h ES8P508x.h
  group Source
    ../Source/: main.c
  group StartUp
    ../../../IAR_StartUp/: startup_hr8p508x.s
