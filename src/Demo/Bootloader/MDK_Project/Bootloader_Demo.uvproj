# Keil uVision project Bootloader_Demo.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ES8P508xFLXX ES
  cpu: IRAM(0x20000000-0x20005FFF)  IROM(0x00000000-0x0001FFFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: Bootloader_Demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\source;..\CMSIS;..\..\..\CMSIS
  memory RVCT4: ROM 0x1e000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group StartUp
    ../../../MDK_StartUp/: startup_ES8P508x.s
  group CMSIS
    ../../../CMSIS/: ES8P508x.h core_cm0.h
  group Source
    ../source/: main.c uart.c lib_flashiap.c systick.c isp_proc.c go.c
