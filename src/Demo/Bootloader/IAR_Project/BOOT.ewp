# IAR project BOOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ES8P508x Eastsoft ES8P508x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\CMSIS; ..\..\..\IAR_StartUp; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BOOT.srec
  ILINK.IlinkOutputFile: BOOT.out
  ILINK.IlinkIcfFile: ES8P508x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../CMSIS/: core_cm0.h ES8P508x.h
  group Source
    ../source/: go.c isp_proc.c lib_flashiap.c main.c systick.c uart.c
  group StartUp
    ../../../IAR_StartUp/: startup_hr8p508x.s
